# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: delay.c lightLed.c main.c switch.c LCD1602.c operationLCD.c digital.c digital-v2.c swithKey.c
